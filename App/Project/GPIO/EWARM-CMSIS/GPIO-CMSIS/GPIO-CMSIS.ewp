# IAR project GPIO-CMSIS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: GPIO-CMSIS.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device.StdPeriph Drivers Framework
    ${CMSIS_PACK_PATH_Keil#STM32F1xx_DFP#2.4.1}$/Device/StdPeriph_Driver/src/: misc.c
    RTE/Device/STM32F103C8/: stm32f10x_conf.h
  group CMSIS-Pack/Device Startup
    RTE/Device/STM32F103C8/: RTE_Device.h system_stm32f10x.c
  group CMSIS-Pack/Device.StdPeriph Drivers GPIO
    ${CMSIS_PACK_PATH_Keil#STM32F1xx_DFP#2.4.1}$/Device/StdPeriph_Driver/src/: stm32f10x_gpio.c
  group CMSIS-Pack/Device.StdPeriph Drivers RCC
    ${CMSIS_PACK_PATH_Keil#STM32F1xx_DFP#2.4.1}$/Device/StdPeriph_Driver/src/: stm32f10x_rcc.c
  group CMSIS-Pack/Device.StdPeriph Drivers TIM
    ${CMSIS_PACK_PATH_Keil#STM32F1xx_DFP#2.4.1}$/Device/StdPeriph_Driver/src/: stm32f10x_tim.c
